# Keil uVision project MFC.uvproj, settings and files
target MFC (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MFC +hex
  c flags: Optimize=8 SizeSpeed=1
  group hardware
    ./hardware/: ADC.c ADC.h Uart1.c Uart1.h PWM.c PID.c PID.h
  group user
    ./user/: main.c public.c public.h
