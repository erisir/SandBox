# Keil uVision project StepMotorDriver.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: StepMotorDriver +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: 1602LCDDriver.c Main.c SerialDriver.c StepMotorDriver.c
