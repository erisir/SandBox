# Keil uVision project MFC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F373RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: MFC +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, USE_STM32373C_EVAL, STM32F37X
  c include: ..\user;..\stm32f3;..\lib\src;..\lib\inc;..\drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_stm32f37x.s
    ../stm32f3/: system_stm32f37x.c
  group user
    ./: main.c
    ../stm32f3/: stm32f37x_conf.h stm32f37x_it.c stm32f37x_it.h
  group drive
    ../hardware/usart/: mfc_usart1.c mfc_usart1.h
    ../hardware/adc/: mfc_adc.c mfc_adc.h
    ../hardware/pid/: mfc_pid.c mfc_pid.h
    ../hardware/pwm/: mfc_pwm.c mfc_pwm.h
  group lib
    ../lib/src/: stm32f37x_gpio.c stm32f37x_rcc.c stm32f37x_usart.c stm32f37x_adc.c stm32f37x_dma.c stm32f37x_sdadc.c stm32f37x_tim.c stm32f37x_misc.c stm32f37x_pwr.c
